# Keil uVision project ECUB_V0.2.uvprojx, settings and files
target ECUB_V0.2 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F105VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ECUB_V0.2
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F105xC,TX_WITH_CANDB=1
  c include: ../Inc;         ../Drivers/STM32F1xx_HAL_Driver/Inc;         ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;         ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;         ../Drivers/CMSIS/Include;         ..\CANdb_ECUB;         ..\Eforce_lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f105xc.s
  group Application/User
    ../Inc/: cooling_circuit.h periphery_set.h stm32f1xx_hal_conf.h stm32f1xx_it.h Wheel_speed.h LvBattery.h Brake_Sensors.h main.h
    ../Src/: ADC.c BrakeLight.c can_callback.c can_eforce_init.c carstate.c cooling_circuit.c periphery_set.c Wheel_speed.c LvBattery.c Brake_Sensors.c main.c stm32f1xx_it.c stm32f1xx_hal_msp.c WatchDog.c
    ../CANdb_ECUB/: can_ECUB.c can_ECUB.h tx2_can.c tx2_ringbuf.c
    ../CANdb_ECUB/tx2/: can.h ringbuf.h tx.h
    ../Eforce_lib/: ltc6804.c ltc6804.h ltc6804_conf.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
software components: CMSIS:CORE 5.0.1
